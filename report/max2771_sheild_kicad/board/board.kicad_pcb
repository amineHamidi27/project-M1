# Repository amineHamidi27/project-M1

## KiCad design report/max2771_sheild_kicad/board/board.kicad_pcb

Parts:
C1, C3, C5, C20: 470pF; C1005
C2: 1.7pF; C1005
C4: 1.1pF; C1005
C6, C10: 750pF; C1005
C7, C11: 15pF; C1005
C8, C12: 0.01uF; C1005
C13, C16, C17, C19, C30, C31, C34, C35, C38, C43: 0.1uF; C1005
C14, C15, C18, C32, C33, C36, C39, C42: 100pF; C1005
CP1, CP2: TestPoint; TestPoint_Pad_2.0x2.0mm
J1, J2, J4: SMA-ANG
J3: Screw_Terminal_01x02; PinHeader_1x02_P2.54mm_Vertical
J5: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
L1: 5.6nF; C1608
L2, L4: 68nH; C1608
L3: 8.4nH; C1608
LED5, LED6: LED1608; LED_1608
P1, P2: Conn_02x10_Odd_Even; PinSocket_2x10_P2.54mm_Vertical
R1, R3: 15K; C1005
R2, R4, R14, R15: 10K; C1005
R5, R7, R10, R11, R17, R20, R24, R25: 0hi nclo; R_0201_0603Metric
R6, R8, R9, R12, R18, R19, R23, R26: 0lo nchi; R_0201_0603Metric
TCXO0: 24.000 MHz 0.5ppm; TCXO
U1, U2: MAX2771; TQFN28

Connections:
+3.3V: C13.1, C16.1, C17.1, C18.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C38.1, C39.1, C42.1, J5.5, P1.10, P1.20, R2.2, R4.2, R14.2, R15.2, TCXO0.4 (VDD), U1.2 (VCCCP), U1.6 (VCCD), U1.14 (VCCADC), U1.22 (VCCRF), U1.27 (VCCIF), U1.28 (VCCVCO), U2.2 (VCCCP), U2.6 (VCCD), U2.14 (VCCADC), U2.22 (VCCRF), U2.27 (VCCIF), U2.28 (VCCVCO)
/5V: C14.2, C15.2, C19.2, C43.2, J3.1, L2.1, L4.1
/PA5: P2.8, R14.1
/PD6: LED5.1 (+), P1.2
/PLL_CLK: C8.1, C12.1, J2.P1 (RF), TCXO0.3 (OUT)
/SLRD: P1.7, R15.1
CP1OUT: C7.1, CP1.1, R1.2, U1.1 (CPOUT)
CP2OUT: C11.1, CP2.1, R3.2, U2.1 (CPOUT)
CPAD_2.2MM: C2.1, C4.2, C6.2, C7.2, C10.2, C11.2, C13.2, C14.1, C15.1, C16.2, C17.2, C18.2, C19.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C38.2, C39.2, C42.2, C43.1, J1.P2 (GND), J1.P3 (GND), J1.P4 (GND), J1.P5 (GND), J2.P2 (GND), J2.P3 (GND), J2.P4 (GND), J2.P5 (GND), J3.2, J4.P2 (GND), J4.P3 (GND), J4.P4 (GND), J4.P5 (GND), J5.1, LED5.2, LED6.2, P1.4, P1.6, P1.8, P1.9, P1.11, P1.19, P2.9, R7.2, R8.2, R19.2, R20.2, TCXO0.1 (NC), TCXO0.2 (GND), U1.5 (ADC_CLKIN), U1.C1 (EP), U1.C2 (EP), U1.C3 (EP), U1.C4 (EP), U1.EP, U1.V1 (EP), U1.V2 (EP), U1.V3 (EP), U1.V4 (EP), U1.V5 (EP), U1.V6 (EP), U1.V7 (EP), U1.V8 (EP), U1.V9 (EP), U2.C1 (EP), U2.C2 (EP), U2.C3 (EP), U2.C4 (EP), U2.EP, U2.V1 (EP), U2.V2 (EP), U2.V3 (EP), U2.V4 (EP), U2.V5 (EP), U2.V6 (EP), U2.V7 (EP)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
CSN_A: P2.5, U1.9 (CSN)
CSN_B: P2.4, U2.9 (CSN)
DCLK: P1.12, U1.4 (CLKOUT), U2.5 (ADC_CLKIN)
I0_A: P1.15, U1.12 (I0)
I0_B: P2.20, U2.12 (I0)
I1_A: P1.16, U1.13 (I1)
I1_B: P2.19, U2.13 (I1)
LOCK_A: P1.1, U1.17 (LD)
LOCK_B: P2.1, U2.17 (LD)
unnamed: C1.1, J1.P1 (RF), L4.2
unnamed: C3.1, J4.P1 (RF), L2.2
unnamed: C1.2, C2.2, L1.1
unnamed: L1.2, R5.2, R6.2
unnamed: C3.2, C4.1, L3.1
unnamed: L3.2, R17.2, R18.2
unnamed: C6.1, R1.1
unnamed: R2.1, U1.18 (SHDN)
unnamed: C10.1, R3.1
unnamed: R4.1, U2.18 (SHDN)
unnamed: R5.1, R8.1, U1.19 (LNAIN_HI)
unnamed: R6.1, R7.1, U1.20 (LNAIN_LO)
unnamed: R9.1, U1.23 (LNAOUT_LO)
unnamed: R10.1, U1.24 (LNAOUT_HI)
unnamed: C5.1, R9.2, R10.2
unnamed: R11.1, U1.25 (MIXIN_HI)
unnamed: C5.2, R11.2, R12.2
unnamed: R12.1, U1.26 (MIXIN_LO)
unnamed: R17.1, R19.1, U2.19 (LNAIN_HI)
unnamed: R18.1, R20.1, U2.20 (LNAIN_LO)
unnamed: R23.1, U2.23 (LNAOUT_LO)
unnamed: C20.1, R23.2, R24.2
unnamed: R24.1, U2.24 (LNAOUT_HI)
unnamed: R25.1, U2.25 (MIXIN_HI)
unnamed: C20.2, R25.2, R26.2
unnamed: R26.1, U2.26 (MIXIN_LO)
unnamed: C8.2, U1.3 (XTAL)
unnamed: C12.2, U2.3 (XTAL)
PA7: J5.2, P2.6
PD7: LED6.1 (+), P1.3
Q0_A: P1.17, U1.11 (Q0)
Q0_B: P2.18, U2.11 (Q0)
Q1_A: P1.18, U1.10 (Q1)
Q1_B: P2.17, U2.10 (Q1)
SCLK: J5.3, P2.3, U1.8 (SCLK), U2.8 (SCLK)
SDATA: J5.4, P2.2, U1.7 (SDATA), U2.7 (SDATA)

Notes on the sheet:
0201 resistors for selecting hi or low band: only set one OR the other on LNA in/mixer in depending on the targeted GNSS band
See AD9851 for tunable DDS controlled source

Board: 4 copper layers, 32.0 x 34.8 mm, 70 parts (2 on the bottom side), 54 nets.

## Commit log

2026-01-18 Create fx2lp
